Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:Off], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: 3DX8A-ASS.ifc
Time: 2025-05-10T22:58:27
Author: PTC-02\RicP
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2021 Service Pack 13, IFC Export Version: 4.0.0.0 Apr 21 2023

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBuildingElementProxy: 3DX8A-ASS, REID-3DX10
In: Undefined
Description: 3DX8A-ASS; Material: STEEL/250
Tekla Common - Bottom elevation: -0.032; Top elevation: +0.033; Phase: 1; Class: 100
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.06 m2; Height: 121.4 mm; Width: 65.2 mm; Length: 210.8 mm
Pours - Pour Weight Net: 0 kg; Pour Weight: 0 kg; Pour Volume: 0 m3; Pour Bottom Level: -0.032; Pour Top Level: +0.033; Pour Material: 250; Pour Content Type: PART; Pour Area NGY: 0 m2; Pour Area PGY: 0 m2; Pour Area NXG: 0 m2; Pour Area PGX: 0 m2; Pour Area NGZ: 0 m2; Pour Area PGZ: 0 m2; Pour Area: 0.1 m2

# IfcElementAssembly, LIFTER
In: Undefined
PredefinedType: RIGID_FRAME
Tekla Assembly - Assembly/Cast unit weight: 0 kg; Assembly/Cast unit bottom elevation: -0.032; Assembly/Cast unit top elevation: +0.033; Assembly/Cast unit position code: A/1; Assembly/Cast unit Mark: P/0(?)
BaseQuantities - Width: 65.2248 mm
